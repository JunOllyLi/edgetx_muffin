## radio/src/targets/common/esp32/components/lvgl_esp32_drivers/Kconfig
```kconfig
menu "LVGL ESP Drivers"

    rsource "lvgl_tft/Kconfig"

    rsource "lvgl_touch/Kconfig"

endmenu
```
